# Keil uVision project bootloader.uvprojx, settings and files
target dfu_dual_bank_hci (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10031 NRF51 NRF51422 DEBUG_NRF_USER BOOTLOADER_BUILD BOOTLOADER_BANKED
  c misc: --reduce_paths
  c include: ..\..\..\include;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\strerror
  asm misc: --cpreproc_opts=-DBOARD_PCA10031,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DESB_PRESENT,-DFLOAT_ABI_HARD,-DNRF51,-DNRF51422
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress 6330
  group Source Code
    ../../../src/: bootloader.c bootloader_util_arm.c dfu_dual_bank.c dfu_single_bank.c dfu_transport_serial.c interrupt_handler.c main.c
    ../../../include/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../components/libraries/crc16/: crc16.c
  group HCI Transport
    ../../../../../../components/libraries/hci/: hci_mem_pool.c hci_slip.c hci_transport.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
